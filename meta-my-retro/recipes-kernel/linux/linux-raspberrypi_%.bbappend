FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://4k_pages.cfg"
SRC_URI += "file://nvme.cfg"