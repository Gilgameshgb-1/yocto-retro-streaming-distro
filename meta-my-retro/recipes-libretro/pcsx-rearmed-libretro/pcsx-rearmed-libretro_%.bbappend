# rpi5 optimized flags
EXTRA_OEMAKE:append = " ARCH=arm64 HAVE_NEON=1 BUILTIN_GPU=neon"